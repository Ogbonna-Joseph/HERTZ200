File: Hertz200/PCB_DESIGN/HERTZ200/HERTZ200.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: ROUTE DONE
Other:
- removed sheet BQ24195_SMPS
- added sheet MP2636 (MP2636.kicad_sch)
